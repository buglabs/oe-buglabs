include osgi.inc

DESCRIPTION = "OSGi Compendium APIs"

SRC_URI = "http://www.osgi.org/download/${PV}/osgi.cmpn.jar"
