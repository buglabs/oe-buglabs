include osgi.inc

DESCRIPTION = "OSGi Core APIs"

SRC_URI = "http://www.osgi.org/download/${PV}/osgi.core.jar"

SRC_URI[md5sum] = "fe78bba6a5aa44cd9f3aef235ed16994"
SRC_URI[sha256sum] = "f61afff1c8ea076b1fb0f935f832bdd2ad7ed5d087ba00bf42606514c2ffe8b4"