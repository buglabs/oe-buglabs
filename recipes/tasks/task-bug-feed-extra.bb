DESCRIPTION = "Additional packages for Bug Labs repository."

PR = "r13"

DEPENDS = "\
	curl \
	dosfstools \
	e2fsprogs \
	psmisc \
	rsync \
	time \
	xournal \
	zip \
	openjdk-6 \
	dhcp \
	opencv \
	fbgrab \
	x11vnc \
	jamvm \
	cacao \
	usb-modeswitch \
#	com.buglabs.bug.jni.bluecove \
	gdbserver \
	ruby \
	"
