require buglabs-osgi.inc
DESCRIPTION = "BUGduino API"

PR = "${INC_PR}.3"
DEPENDS += "com.buglabs.common com.buglabs.bug.ws com.buglabs.bug.base.bug20" 

BUNDLE_PERM = "0744"
