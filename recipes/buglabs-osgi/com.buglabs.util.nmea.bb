require buglabs-osgi.inc

DESCRIPTION = "GPS parsing and unit code."
LICENSE = "BSD"

PR = "${INC_PR}.4"
