require buglabs-osgi.inc

DESCRIPTION = "BUG Legacy APIs for compile-time backwards compatibility."
LICENSE = "BSD"

PR = "${INC_PR}.0"
DEPENDS += " felix-configadmin org.apache.felix.http.base"
