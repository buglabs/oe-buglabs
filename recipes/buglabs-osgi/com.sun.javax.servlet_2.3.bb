ANT_TARGETS = "create_dirs build.jars append.resources"

require buglabs-osgi.inc

DESCRIPTION = "Servlet API 2.3"

PR = "${INC_PR}.5"
