require bug-osgi.inc

DESCRIPTION = "GPS parsing and unit code."
PR = "${INC_PR}.3+svnr${SRCREV}"
