DESCRIPTION = "BUG bundle com.buglabs.util.shell"
LICENSE = "BSD"

PR = "7"
DEPENDS += "com.buglabs.common"

require buglabs-osgi.inc



