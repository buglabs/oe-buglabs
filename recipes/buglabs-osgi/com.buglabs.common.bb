DESCRIPTION = "Common code for BUG OSGi bundles."
LICENSE = "BSD"

PR = "12"
DEPENDS += "felix-configadmin"

require buglabs-osgi.inc
