require felix-binary-bundle.inc

DESCRIPTION = "R4 Compliant OSGi HTTP Service API"
SRC_URI[md5sum] = "e60f3973204232b66e18dc7784b08034"
SRC_URI[sha256sum] = "b1d8f041596688c4b36d2862731503a25ad1c05ae47d5a832237a4e5cc03117d"
