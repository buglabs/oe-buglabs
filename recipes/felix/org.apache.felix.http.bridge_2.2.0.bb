require felix-binary-bundle.inc

DESCRIPTION = "R4 Compliant OSGi HTTP Service Bridge"
SRC_URI[md5sum] = "45533230853d1b80993b359169b498dd"
SRC_URI[sha256sum] = "ba8c7737c004c2ca74a155bc0b59192c72918816b0b5afa4560afdf94bb95b84"

