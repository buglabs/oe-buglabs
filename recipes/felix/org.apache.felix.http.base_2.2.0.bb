require felix-binary-bundle.inc

DESCRIPTION = "R4 Compliant OSGi HTTP Service Base API"
SRC_URI[md5sum] = "e57b9d2a35a801fd7ac271f00ce39720"
SRC_URI[sha256sum] = "cbb90fe3e9badc2d9c4b296e7450b86eecb26f813379745badf76aee7ad54b9f"
