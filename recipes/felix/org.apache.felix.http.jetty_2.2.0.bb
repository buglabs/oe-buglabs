require felix-binary-bundle.inc

DESCRIPTION = "R4 Compliant OSGi HTTP Service using Jetty."

SRC_URI[md5sum] = "cab4792b9b12ae28e0c77f9e47c46589"
SRC_URI[sha256sum] = "aa5b51b62f392e402b6ff36b78f1a3a30c969c2e1e7b38915545ba5ac34f3909"

