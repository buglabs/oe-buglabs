require felix-binary-bundle.inc

DESCRIPTION = "R4 Compliant OSGi HTTP Service Whiteboard"

SRC_URI[md5sum] = "ff96b6b6bba11f37ccef8d255dc7998d"
SRC_URI[sha256sum] = "26563acce5e90548b34182a025c4c068846d69a0d40e19494d34fefeb821676f"

